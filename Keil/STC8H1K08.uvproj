# Keil uVision project STC8H1K08.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: STC8H1K08 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: __CX51__, __CONF_MCU_MODEL=MCU_MODEL_STC8H3K32S2,__CONF_FOSC=36864000UL
  c include: .\FwLib_STC8\include
  group Source Group 1
    ./: main.c STARTUP.A51
